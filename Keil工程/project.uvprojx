# Keil uVision project project.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00007800) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_LD
  c include: .\USER;.\CODE;..\参考\7-1 AD单通道\7-1 AD单通道\Start;..\参考\7-1 AD单通道\7-1 AD单通道\Library;..\参考\7-1 AD单通道\7-1 AD单通道\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7800
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Start
    ../参考/7-1 AD单通道/7-1 AD单通道/Start/: startup_stm32f10x_ld.s system_stm32f10x.c core_cm3.c
  group StdPeriph
    ../参考/7-1 AD单通道/7-1 AD单通道/Library/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ./USER/: main.c
  group CODE
    ./CODE/: delay.c led.c dht11.c key.c usart.c timer.c ADC_LDR.c display.c SR04.c beep_init.c app_config.c app_eventlog.c app_fusion.c app_diag.c
